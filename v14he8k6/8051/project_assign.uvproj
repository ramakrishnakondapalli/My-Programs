# Keil uVision project project_assign.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: project_assign +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: spi_adcmcp3204_main.c spi_adcmcp3204.h spi_adcmcp3204.c UART.c UART.h
