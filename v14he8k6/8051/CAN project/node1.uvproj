# Keil uVision project node1.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: node1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: headers.h defines.h spi.h spi.c canfun.c canfun.h main.c types.h
