# Keil uVision project project1.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: project1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/v14he8k6/CAN project/: canfun.c spi.c main.c
