# Keil uVision project tx1.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LV51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: tx1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: canfun2.c main2.c spi2.c
