# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C51RD2xx Philips
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: headers.h defines.h TYPES.H SPI.H CANFUNC.H CAN_FUNC.C main.c
    ../: SPI.C
